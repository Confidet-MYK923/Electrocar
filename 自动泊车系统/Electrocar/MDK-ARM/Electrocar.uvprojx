# Keil uVision project Electrocar.uvprojx, settings and files
target Electrocar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Electrocar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/HARDWORD/control;../Core/HARDWORD/encoder;../Core/HARDWORD/KEY;../Core/HARDWORD/MOTOR;../Core/HARDWORD/MPU6050;../Core/HARDWORD/OLED;../Core/HARDWORD/servo;../Core/HARDWORD/PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group HARDWORD
    ../Core/HARDWORD/control/: control.c
    ../Core/HARDWORD/encoder/: encoder.c
    ../Core/HARDWORD/KEY/: key.c
    ../Core/HARDWORD/MOTOR/: motor.c
    ../Core/HARDWORD/MPU6050/: IIC.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../Core/HARDWORD/servo/: servo.c
    ../Core/HARDWORD/PID/: pid.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
